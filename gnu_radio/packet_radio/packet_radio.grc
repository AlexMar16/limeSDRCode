<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>400000</value></param>
</block>
<block>
<key>blks2_packet_encoder</key>
<param><key>id</key><value>blks2_packet_encoder_0</value></param>
<param><key>access_code</key><value>1100110011</value></param>
<param><key>bits_per_symbol</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>pad_for_usrp</key><value>True</value></param>
<param><key>payload_length</key><value>0</value></param>
<param><key>preamble</key><value></value></param>
<param><key>samples_per_symbol</key><value>1</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/doctor/harro.txt</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_gmsk_mod</key>
<param><key>id</key><value>digital_gmsk_mod_0</value></param>
<param><key>bt</key><value>0.35</value></param>
<param><key>samples_per_symbol</key><value>2</value></param>
</block>
<block>
<key>limesdr_sink</key>
<param><key>id</key><value>limesdr_sink_0</value></param>
<param><key>channel</key><value>0</value></param>
<param><key>analog_bandw_ch0</key><value>6e6</value></param>
<param><key>analog_filter_ch0</key><value>1</value></param>
<param><key>cmix_mode_ch0</key><value>0</value></param>
<param><key>calibr_bandw_ch0</key><value>10e6</value></param>
<param><key>calibration_ch0</key><value>0</value></param>
<param><key>digital_bandw_ch0</key><value>0</value></param>
<param><key>digital_filter_ch0</key><value>0</value></param>
<param><key>gain_dB_ch0</key><value>30</value></param>
<param><key>pa_path_ch0</key><value>1</value></param>
<param><key>pa_path_mini</key><value>1</value></param>
<param><key>analog_filter_ch1</key><value>1</value></param>
<param><key>cmix_mode_ch1</key><value>0</value></param>
<param><key>calibr_bandw_ch1</key><value>10e6</value></param>
<param><key>calibration_ch1</key><value>0</value></param>
<param><key>digital_bandw_ch1</key><value>0</value></param>
<param><key>digital_filter_ch1</key><value>0</value></param>
<param><key>gain_dB_ch1</key><value>30</value></param>
<param><key>pa_path_ch1</key><value>1</value></param>
<param><key>chip_mode</key><value>1</value></param>
<param><key>serial</key><value>0009070602433917</value></param>
<param><key>device_type</key><value>2</value></param>
<param><key>file_switch</key><value>0</value></param>
<param><key>oversample</key><value>0</value></param>
<param><key>rf_freq</key><value>860e6</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<connection><source_block_id>blks2_packet_encoder_0</source_block_id><sink_block_id>digital_gmsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blks2_packet_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_mod_0</source_block_id><sink_block_id>limesdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
